# Keil uVision project crazypony.uvproj, settings and files
target crazypony (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: crazypony
  c flags: Optim=1 wLevel=1
  c define: BOARD_REV_E STM32F10X_MD
  c include: .\lib\FreeRTOS\include;.\lib\FreeRTOS\portable\GCC\ARM_CM3;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\CMSIS\Core\CM3;.\config;.\hal\interface;.\modules\interface;.\utils\interface;.\drivers\interface
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: crazypony.sct
  group drivers
    ./drivers/src/: adc.c exti.c hmc5883l.c i2cdev.c i2croutines.c led.c motors.c mpu6050.c ms5611.c nrf24l01.c nvic.c
  group modules
    ./modules/src/: comm.c commander.c console.c controller.c crtp.c crtpservice.c log.c param.c pid.c pidctrl.c sensfusion6.c stabilizer.c system.c worker.c
  group hal
    ./hal/src/: eskylink.c freeRTOSdebug.c imu.c ledseq.c pm.c radiolink.c uart.c usec_time.c
  group init
    ./init/: main.c
  group lib
    ./lib/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ./lib/FreeRTOS/portable/MemMang/: heap_4.c
    ./lib/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./lib/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group utils
    ./utils/src/: abort.c cfassert.c configblock.c cpuid.c crc.c debug.c eprintf.c filter.c fp16.c
